# Keil uVision project dzxlsj.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dzxlsj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./source/: main.c ADC.c ADC.h C8051F020.h DAC.c DAC.h Delay.c Delay.h SYS_Init.c SYS_Init.h Timer.c Timer.h lcd.c led.c pid.c queue.c picture.h pid.h queue.h
